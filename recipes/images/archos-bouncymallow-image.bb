require archos-qt4-image.bb

ANGSTROM_EXTRA_INSTALL += " bouncymallow bouncymallow-init "

export IMAGE_BASENAME = "archos-bouncymallow-image"
