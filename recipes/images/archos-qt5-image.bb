require archos-console-image.bb

ANGSTROM_EXTRA_INSTALL += " qt5-embedded "

export IMAGE_BASENAME = "archos-qt5-image"
